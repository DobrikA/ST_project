# Keil uVision project uart_adc_project.uvprojx, settings and files
target uart_adc (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart_adc_project
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427X,USE_UART_DMA
  c include: ..\UART+ADC;.\user_lib\src;.\user_lib\inc;.\user_rtos\src;.\user_rtos\inc;..\STM32F4xx_StdPeriph_Driver\src;..\STM32F4xx_StdPeriph_Driver\inc;.\ST_user;..\Common_lib\src;..\Common_lib\inc;..\Third_party_lib\FreeRTOS\FreeRTOS_8.0.1;..\Third_party_lib\FreeRTOS\FreeRTOS_8.0.1\Source;..\Third_party_lib\FreeRTOS\FreeRTOS_8.0.1\Source\include;..\Third_party_lib\FreeRTOS\FreeRTOS_8.0.1\Source\portable\RVDS\ARM_CM4F;..\Third_party_lib\FreeRTOS\FreeRTOS_8.0.1\Source\portable\MemMang
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./: main.c
  group ST_lib
    ../STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_dma.c misc.c stm32f4xx_adc.c stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_rcc.c
  group rtos
    ../Third_party_lib/FreeRTOS/FreeRTOS_8.0.1/Source/portable/MemMang/: heap_2.c
    ../Third_party_lib/FreeRTOS/FreeRTOS_8.0.1/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Third_party_lib/FreeRTOS/FreeRTOS_8.0.1/Source/: queue.c tasks.c list.c croutine.c
  group user_lib
    ./user_lib/src/: uart.c irq_routine.c dev_data_routine.c adc_timer.c adc_routine.c dma_routine.c gpio_timer.c gpio_cntrl.c
    ./user_rtos/src/: dev_rtos_routine.c
    ../Common_lib/src/: crc_calc.c
software components: CMSIS:CORE 5.5.0, Device:Startup 2.6.3
